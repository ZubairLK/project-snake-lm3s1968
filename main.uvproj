# Keil uVision project main.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S1968 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: main
  c flags: Optim=1
  c define: rvmdk PART_LM3S1968
  c include: ..;C:\StellarisWare
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: Startup.s main.c rit128x96x4.c my_init.c snake.c class-d.c class-d.h my_sounds.h my_sounds.c
  group Libraries
    C:/StellarisWare/driverlib/rvmdk-cm3/: driverlib-cm3.lib
